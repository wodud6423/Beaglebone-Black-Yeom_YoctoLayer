SUMMARY = "Device tree overlay for YEOM LCD on BeagleBone Black"
LICENSE =""
SRC_URI ="file://am335x-beaglebone-yeom.dts"

S=
